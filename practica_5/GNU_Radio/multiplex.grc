options:
  parameters:
    generate_options: qt_gui
    id: MultiplexaPAM
    output_language: python
    title: MultiplexaPAM
  states: {}

blocks:
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud mensaje
    start: '0'
    step: '0.1'
    stop: '5'
    value: '1'
  states: {}
- name: D
  id: variable_qtgui_range
  parameters:
    label: Ancho pulso
    start: '0'
    step: '1'
    stop: '50'
    value: '20'
  states: {}
- name: D1
  id: variable_qtgui_range
  parameters:
    label: Retardo 1
    start: '0'
    step: '1'
    stop: '100'
    value: '20'
  states: {}
- name: D2
  id: variable_qtgui_range
  parameters:
    label: Retardo 2
    start: '0'
    step: '1'
    stop: '100'
    value: '40'
  states: {}
- name: D3
  id: variable_qtgui_range
  parameters:
    label: Retardo 3
    start: '0'
    step: '1'
    stop: '100'
    value: '60'
  states: {}
- name: D4
  id: variable_qtgui_range
  parameters:
    label: Retardo 4
    start: '0'
    step: '1'
    stop: '100'
    value: '80'
  states: {}
- name: D5
  id: variable_qtgui_range
  parameters:
    label: Seleccion de señal RX
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: fc_LPF
  id: variable_qtgui_range
  parameters:
    label: fracuencia corte
    start: '0'
    step: '1'
    stop: 10e3
    value: '50'
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: frecuencia mensaje
    start: '0'
    step: '10'
    stop: 10e3
    value: '100'
  states: {}
- name: fs
  id: variable_qtgui_range
  parameters:
    label: Frecuencia pulsos
    start: '0'
    step: '1'
    stop: 10e3
    value: samp_rate/100
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 25e6/64
  states: {}
- name: ModulacionPAM_0
  id: ModulacionPAM
  parameters:
    D: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: ModulacionPAM_0_0
  id: ModulacionPAM
  parameters:
    D: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: ModulacionPAM_0_1
  id: ModulacionPAM
  parameters:
    D: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: ModulacionPAM_0_2
  id: ModulacionPAM
  parameters:
    D: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: ModulacionPAM_0_2_0
  id: ModulacionPAM
  parameters:
    D: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: ModulacionPAM_1
  id: ModulacionPAM
  parameters:
    D: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_TRI_WAVE
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: analog_sig_source_x_0_2
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '5'
    type: float
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: D1
    type: float
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: D2
    type: float
  states: {}
- name: blocks_delay_0_1
  id: blocks_delay
  parameters:
    delay: D3
    type: float
  states: {}
- name: blocks_delay_0_1_0
  id: blocks_delay
  parameters:
    delay: D4
    type: float
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: D5
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_wavfile_source_1
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\maquina_leandro\Downloads\despecha_rosalia.wav
    repeat: 'True'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: fc_LPF
    decim: '1'
    gain: '4'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '16384'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    color5: magenta
    gui_hint: 3,0,6,2
    nconnections: '6'
    size: 1024*4
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 3,2,6,2
    nconnections: '2'
    size: 1024*8
    srate: samp_rate
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '44100'
    interp: int(samp_rate)
    type: fff
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: 200e6
    gain0: '30'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {state: disabled}

connections:
- [ModulacionPAM_0, '0', blocks_add_xx_0, '0']
- [ModulacionPAM_0, '0', qtgui_time_sink_x_0, '0']
- [ModulacionPAM_0_0, '0', blocks_delay_0, '0']
- [ModulacionPAM_0_1, '0', blocks_delay_0_0, '0']
- [ModulacionPAM_0_2, '0', blocks_delay_0_1, '0']
- [ModulacionPAM_0_2_0, '0', blocks_delay_0_1_0, '0']
- [ModulacionPAM_1, '0', blocks_float_to_complex_0, '0']
- [ModulacionPAM_1, '0', low_pass_filter_0, '0']
- [ModulacionPAM_1, '0', qtgui_time_sink_x_1, '0']
- [analog_sig_source_x_0, '0', ModulacionPAM_0, '0']
- [analog_sig_source_x_0_0, '0', ModulacionPAM_0_0, '0']
- [analog_sig_source_x_0_1, '0', ModulacionPAM_0_1, '0']
- [analog_sig_source_x_0_2, '0', ModulacionPAM_0_2, '0']
- [blocks_add_xx_0, '0', blocks_delay_1, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0, '4']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0, '5']
- [blocks_delay_0, '0', blocks_add_xx_0, '1']
- [blocks_delay_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_delay_0_0, '0', blocks_add_xx_0, '2']
- [blocks_delay_0_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_delay_0_1, '0', blocks_add_xx_0, '3']
- [blocks_delay_0_1, '0', qtgui_time_sink_x_0, '3']
- [blocks_delay_0_1_0, '0', blocks_add_xx_0, '4']
- [blocks_delay_1, '0', ModulacionPAM_1, '0']
- [blocks_float_to_complex_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_float_to_complex_0, '0', uhd_usrp_sink_0, '0']
- [blocks_wavfile_source_1, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_1, '1']
- [rational_resampler_xxx_0, '0', ModulacionPAM_0_2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
