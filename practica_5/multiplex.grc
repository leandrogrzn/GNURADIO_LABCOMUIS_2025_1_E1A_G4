options:
  parameters:
    generate_options: qt_gui
    id: MultiplexaPAM
    output_language: python
    title: MultiplexaPAM
  states: {}

blocks:
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud mensaje
    start: '0'
    step: '0.1'
    stop: '5'
    value: '1'
  states: {}
- name: D
  id: variable_qtgui_range
  parameters:
    label: Ancho pulso
    start: '0'
    step: '1'
    stop: '50'
    value: '10'
  states: {}
- name: D1
  id: variable_qtgui_range
  parameters:
    label: Retardo 1
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: D2
  id: variable_qtgui_range
  parameters:
    label: Retardo 2
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: D3
  id: variable_qtgui_range
  parameters:
    label: Retardo 3
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: D4
  id: variable_qtgui_range
  parameters:
    label: Retardo 4
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: frecuencia mensaje
    start: '0'
    step: '10'
    stop: 10e3
    value: '100'
  states: {}
- name: fs
  id: variable_qtgui_range
  parameters:
    label: Frecuencia Pulsos
    start: '0'
    step: '1'
    stop: 10e3
    value: 1e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: ModulacionPAM_0
  id: ModulacionPAM
  parameters:
    D: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: ModulacionPAM_0_0
  id: ModulacionPAM
  parameters:
    D: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: ModulacionPAM_0_1
  id: ModulacionPAM
  parameters:
    D: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: ModulacionPAM_0_2
  id: ModulacionPAM
  parameters:
    D: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: ModulacionPAM_0_2_0
  id: ModulacionPAM
  parameters:
    D: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_TRI_WAVE
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: analog_sig_source_x_0_2
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '5'
    type: float
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: D1
    type: float
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: D2
    type: float
  states: {}
- name: blocks_delay_0_1
  id: blocks_delay
  parameters:
    delay: D3
    type: float
  states: {}
- name: blocks_delay_0_1_0
  id: blocks_delay
  parameters:
    delay: D4
    type: float
  states: {}
- name: blocks_wavfile_source_1
  id: blocks_wavfile_source
  parameters:
    file: /home/com1_E1A_G4/Descargas/despecha_rosalia.wav
    repeat: 'True'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    color5: magenta
    nconnections: '6'
    size: 1024*4
    srate: samp_rate
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '44100'
    interp: int(samp_rate)
    type: fff
  states: {}

connections:
- [ModulacionPAM_0, '0', blocks_add_xx_0, '0']
- [ModulacionPAM_0, '0', qtgui_time_sink_x_0, '0']
- [ModulacionPAM_0_0, '0', blocks_delay_0, '0']
- [ModulacionPAM_0_1, '0', blocks_delay_0_0, '0']
- [ModulacionPAM_0_2, '0', blocks_delay_0_1, '0']
- [ModulacionPAM_0_2_0, '0', blocks_delay_0_1_0, '0']
- [analog_sig_source_x_0, '0', ModulacionPAM_0, '0']
- [analog_sig_source_x_0_0, '0', ModulacionPAM_0_0, '0']
- [analog_sig_source_x_0_1, '0', ModulacionPAM_0_1, '0']
- [analog_sig_source_x_0_2, '0', ModulacionPAM_0_2, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0, '5']
- [blocks_delay_0, '0', blocks_add_xx_0, '1']
- [blocks_delay_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_delay_0_0, '0', blocks_add_xx_0, '2']
- [blocks_delay_0_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_delay_0_1, '0', blocks_add_xx_0, '3']
- [blocks_delay_0_1, '0', qtgui_time_sink_x_0, '3']
- [blocks_delay_0_1_0, '0', blocks_add_xx_0, '4']
- [blocks_delay_0_1_0, '0', qtgui_time_sink_x_0, '4']
- [blocks_wavfile_source_1, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', ModulacionPAM_0_2_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.11.0-89-ga17f69e7
