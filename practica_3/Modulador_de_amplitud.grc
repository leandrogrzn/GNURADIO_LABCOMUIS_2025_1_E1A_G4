options:
  parameters:
    generate_options: qt_gui
    id: Modulador_de_amplitud
    output_language: python
    title: Modulador_de_amplitud
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud portadora
    start: '0'
    step: '0.01'
    stop: '0.25'
    value: '0.125'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud mensaje
    start: '0'
    step: '100e-3'
    stop: '4'
    value: '1'
  states: {}
- name: B
  id: variable_qtgui_range
  parameters:
    label: muestras por simbolo
    start: '0'
    step: '1'
    stop: '20'
    value: '10'
  states: {state: disabled}
- name: GTX
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '30'
    value: '15'
  states: {}
- name: K
  id: variable_qtgui_range
  parameters:
    label: habilita portadora
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia Portadora MHZ
    start: '50'
    step: '1'
    stop: '2200'
    value: '200'
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '100'
    stop: samp_rate/10
    value: '1000'
  states: {}
- name: ka
  id: variable_qtgui_range
  parameters:
    label: coeficiente ka
    start: '0'
    step: '0.1'
    stop: '5'
    value: '1'
  states: {}
- name: n
  id: variable
  parameters:
    value: '3'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 25e6/32
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: int(math.pow(2,n))
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_add_const_vxx_1
  id: blocks_add_const_vxx
  parameters:
    const: (math.pow(2,n)-1)/2
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 2/(math.pow(2,n)-1)
    type: float
  states: {state: disabled}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: int(B)
    type: float
  states: {state: disabled}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/com1_E1A_G4/labcom/GNURADIO_LABCOMUIS_2025_1_E1A_G4/practica_2/labachata_manuelturizo.wav
    repeat: 'True'
  states: {}
- name: envolventecompleja_0
  id: envolventecompleja
  parameters:
    Ac: Ac
    Ka: ka
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import math
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '44100'
    interp: int(samp_rate)
    type: fff
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc*1e6
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: m_t
  states: {state: disabled}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: m_t
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: m_t
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_uchar_to_float_0, '0']
- [analog_sig_source_x_0, '0', envolventecompleja_0, '0']
- [blocks_add_const_vxx_1, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', virtual_sink_0, '0']
- [blocks_repeat_0, '0', blocks_add_const_vxx_1, '0']
- [blocks_uchar_to_float_0, '0', blocks_repeat_0, '0']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_0, '0']
- [envolventecompleja_0, '0', qtgui_freq_sink_x_0, '0']
- [envolventecompleja_0, '0', qtgui_time_sink_x_0, '0']
- [envolventecompleja_0, '0', uhd_usrp_sink_0, '0']
- [rational_resampler_xxx_0, '0', virtual_sink_1, '0']
- [virtual_source_0, '0', envolventecompleja_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.11.0-89-ga17f69e7
