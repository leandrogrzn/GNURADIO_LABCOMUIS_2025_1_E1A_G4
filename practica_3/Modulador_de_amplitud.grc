options:
  parameters:
    generate_options: qt_gui
    id: Modulador_de_amplitud
    output_language: python
    title: Modulador_de_amplitud
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud portadora
    start: '0'
    step: '0.01'
    stop: '0.25'
    value: '0.125'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud mensaje
    start: '0'
    step: '100e-3'
    stop: '4'
    value: '1'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '30'
    value: '15'
  states: {}
- name: K
  id: variable_qtgui_range
  parameters:
    label: habilita portadora
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia Portadora MHZ
    start: '50'
    step: '1'
    stop: '2200'
    value: '200'
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '100'
    stop: samp_rate/10
    value: '1000'
  states: {}
- name: ka
  id: variable_qtgui_range
  parameters:
    label: coeficiente ka
    start: '0'
    step: '0.1'
    stop: '5'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.5625e6
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: envolventecompleja_0
  id: envolventecompleja
  parameters:
    Ac: Ac
    Ka: ka
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc*1e6
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', envolventecompleja_0, '0']
- [envolventecompleja_0, '0', qtgui_freq_sink_x_0, '0']
- [envolventecompleja_0, '0', qtgui_time_sink_x_0, '0']
- [envolventecompleja_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.11.0-89-ga17f69e7
