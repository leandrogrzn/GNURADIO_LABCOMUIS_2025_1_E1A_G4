options:
  parameters:
    author: Oscar Reyes / Efrén Acevedo
    generate_options: qt_gui
    id: filters_flowgraph
    output_language: python
    title: Flowgraph to test filters using GNU Radio
  states: {}

blocks:
- name: GTX
  id: variable_qtgui_range
  parameters:
    comment: Ganancia del transmisor
    gui_hint: tab_usrp@0:2,0
    label: Tx gain in dB
    start: '0'
    step: '1'
    stop: '30'
    value: '30'
  states: {}
- name: amplitude
  id: variable_qtgui_range
  parameters:
    comment: |-
      Bloque ajuste de variables 
      mientras se ejecuta el flujograma
    gui_hint: tab_source@0:1,0
    label: Amplitude
    start: '0'
    step: '0.1'
    stop: '0.5'
    value: '0.5'
  states: {}
- name: desv_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: tab_channel@0:1,0
    label: Frequency Offset
    start: '0'
    step: '10'
    stop: '10000'
    value: '0'
  states: {}
- name: f_max
  id: variable_qtgui_range
  parameters:
    gui_hint: tab_channel@0:4,0
    label: High Cutoff Frequency in Hz
    start: '0'
    step: '10'
    stop: 21.05e3
    value: '5000'
  states: {}
- name: f_min
  id: variable_qtgui_range
  parameters:
    gui_hint: tab_channel@0:3,0
    label: Low Cutoff Frequency in Hz
    start: '10'
    step: '10'
    stop: 5e3
    value: '100'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    comment: Frecuencia de portadora
    gui_hint: tab_usrp@0:1,0
    label: Carrier Frequency in MHz
    start: '50'
    step: '0.1'
    stop: '2200'
    value: '100'
  states: {}
- name: frequency
  id: variable_qtgui_range
  parameters:
    gui_hint: tab_source@0:2,0
    label: Frequency in Hz
    start: '0'
    step: '100'
    stop: 1e4
    value: 1e3
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    comment: Amplitud del ruido
    gui_hint: tab_channel@0:0,0
    label: Noise voltage
    start: '0'
    step: '0.01'
    stop: '0.5'
    value: '0'
  states: {}
- name: offset
  id: variable_qtgui_range
  parameters:
    gui_hint: tab_source@0:1,1
    label: Offset
    start: '-5'
    step: '0.1'
    stop: '5'
    value: '0'
  states: {}
- name: phase
  id: variable_qtgui_range
  parameters:
    gui_hint: tab_source@0:2,1
    label: Phase Rad
    start: '0'
    step: '0.1'
    stop: 2*np.pi
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: |-
      Bloque usado para configurar 
      valores de variables que no se
      van a actualizar durante la ejecución
    value: 25e6/128
  states: {}
- name: sink_type
  id: variable_qtgui_chooser
  parameters:
    comment: |-
      Bloque usado para habilitar 
      o deshabilitar la salida de 
      audio del sistema.
    gui_hint: tab_source@0:0,1
    label: Output
    labels: '["Mute", "Speaker"]'
    num_opts: '0'
    options: '[0, 1]'
    orient: Qt.QHBoxLayout
    type: raw
    value: '0'
    widget: radio_buttons
  states: {}
- name: source_type
  id: variable_qtgui_chooser
  parameters:
    comment: |-
      Bloque usado para cambiar 
      el tipo de dato de la fuente
      (complejo o flotante)
    gui_hint: tab_source@0:0,0
    label: Source Type
    labels: '["Complex", "Float", "Microphone", "WAV File"]'
    num_opts: '0'
    options: '[0, 1, 2, 3]'
    type: raw
    value: '1'
  states: {}
- name: waveform
  id: variable_qtgui_chooser
  parameters:
    comment: |-
      Bloque usado para cambiar 
      los tipos de formas de onda
    gui_hint: tab_source@0:0,2
    label: Waveform
    labels: '["Constant", "Sine", "Cosine", "Square", "Triangle", "Saw Tooth"]'
    num_opts: '0'
    options: '[100, 101, 102, 103, 104, 105]'
    type: raw
    value: '104'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: amplitude
    comment: |-
      Fuente virtual COMPLEJA, 
      genera diferentes formas de onda
    freq: frequency
    offset: offset
    phase: phase
    samp_rate: samp_rate
    type: complex
    waveform: waveform
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: amplitude
    comment: |-
      Fuente virtual REAL, 
      genera diferentes formas de onda
    freq: frequency
    offset: offset
    phase: phase
    samp_rate: samp_rate
    type: float
    waveform: waveform
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: int(samp_rate)
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: int(samp_rate)
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    comment: Modela el filtro de recepción.
    gain: '1'
    high_cutoff_freq: f_max
    interp: '1'
    low_cutoff_freq: f_min
    samp_rate: samp_rate
    type: interp_fir_filter_ccf
    width: '100'
    win: window.WIN_BLACKMAN
  states: {state: disabled}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: source_type
    num_inputs: '4'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: sink_type
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    comment: |-
      Deshabilite este bloque si usa un 
      USRP. Solo se usa en SIMULACIÓN 
      para regular el flujo de datos.
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    comment: |-
      Recuerde usar "/" en Linux y "\" en Windows
      para describir la ruta del archivo
    file: /home/com1_E1A_G4/labcom/GNURADIO_LABCOMUIS_2025_1_E1A_G4/practica_2/harvard.wav
    repeat: 'True'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: desv_freq/samp_rate
    noise_voltage: noise
    seed: '0'
    taps: '1.0'
  states: {}
- name: import_1
  id: import
  parameters:
    comment: |-
      Usado para importar modulos 
      de python adicionales
    imports: import numpy as np
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '16384'
    grid: 'True'
    gui_hint: tab_plots@1:0,0,6,2
    label: Relative Gain BEFORE Filter
    type: complex
    wintype: window.WIN_RECTANGULAR
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '16384'
    grid: 'True'
    gui_hint: tab_plots@1:0,2,6,2
    label: Relative Gain AFTER Filter
    type: complex
    wintype: window.WIN_RECTANGULAR
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: tab_plots@0:0,0,6,2
    label1: Real
    label2: Imag
    size: '1024'
    srate: samp_rate
    type: complex
    ylabel: Amplitude BEFORE Filter
    yunit: V
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: tab_plots@0:0,2,6,2
    label1: Real
    label2: Imag
    size: '1024'
    srate: samp_rate
    type: complex
    ylabel: Amplitude AFTER Filter
    yunit: V
  states: {}
- name: tab_channel
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,2,3,1
    label0: Channel Controls
    num_tabs: '1'
  states: {}
- name: tab_plots
  id: qtgui_tab_widget
  parameters:
    gui_hint: 3,0,6,4
    label0: Time Domain Plots
    label1: Frequency Domain Plots
    num_tabs: '2'
  states: {}
- name: tab_source
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,3,2
    label0: Source Controls
    num_tabs: '1'
  states: {}
- name: tab_usrp
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,3,3,1
    label0: USRP Controls
    num_tabs: '1'
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc*1e6
    comment: |-
      Deshabilite este bloque si 
      no hace uso del USRP. 
      Este es el transmisor del sistema.
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: fc*1e6
    comment: |-
      Deshabilite este bloque si 
      no hace uso del receptor USRP. 
      Este es el receptor del sistema.
    rx_agc0: Enabled
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    comment: Source + Channel model
    stream_id: after_filter
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    comment: |-
      Fuente + Efectos de 
      modelo de canal
    stream_id: source
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    comment: |-
      Deshabilite este bloque si usa un 
      USRP. Solo se usa en SIMULACIÓN 
      para conectar la señal proveniente
      del modelo de canal inalámbrico.
    stream_id: before_filter
  states: {state: disabled}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    comment: |-
      Deshabilite este bloque si 
      no hace uso del USRP (ni como 
      TX, ni como RX). 
      Este bloque le pasa la señal 
      recibida por el USRP al filtro.
    stream_id: before_filter
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: source
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    comment: |-
      Deshabilite este bloque
      si usa el RX USRP
    stream_id: source
  states: {state: disabled}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: before_filter
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: after_filter
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_selector_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_float_to_complex_0, '0']
- [audio_source_0, '0', blocks_float_to_complex_0_0, '0']
- [band_pass_filter_0, '0', blocks_complex_to_real_0, '0']
- [band_pass_filter_0, '0', virtual_sink_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_float_to_complex_1, '0']
- [blocks_complex_to_mag_0, '0', blocks_selector_1, '0']
- [blocks_complex_to_real_0, '0', blocks_selector_1, '0']
- [blocks_float_to_complex_0, '0', blocks_selector_0, '1']
- [blocks_float_to_complex_0_0, '0', blocks_selector_0, '2']
- [blocks_float_to_complex_0_0_0, '0', blocks_selector_0, '3']
- [blocks_float_to_complex_1, '0', virtual_sink_0, '0']
- [blocks_selector_0, '0', channels_channel_model_0, '0']
- [blocks_selector_1, '0', blocks_null_sink_0, '0']
- [blocks_selector_1, '1', audio_sink_0, '0']
- [blocks_throttle2_0, '0', virtual_sink_1, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0_0_0, '0']
- [channels_channel_model_0, '0', blocks_throttle2_0, '0']
- [channels_channel_model_0, '0', virtual_sink_0_0, '0']
- [uhd_usrp_source_0, '0', virtual_sink_1_0, '0']
- [virtual_source_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_0, '0', qtgui_time_sink_x_0, '0']
- [virtual_source_0, '0', uhd_usrp_sink_0_0, '0']
- [virtual_source_0_0, '0', virtual_sink_1_0, '0']
- [virtual_source_1, '0', band_pass_filter_0, '0']
- [virtual_source_1, '0', blocks_complex_to_mag_0, '0']
- [virtual_source_1_0, '0', qtgui_freq_sink_x_0_0, '0']
- [virtual_source_1_0, '0', qtgui_time_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.11.0-89-ga17f69e7
